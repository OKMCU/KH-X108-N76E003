# Keil uVision project KH-X108.uvproj, settings and files
target KH-X108 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: KH-X108 +hex
  c include: ..\..\trunk
  group BSP
    ../bsp/: STARTUP.A51 interrupt.c bsp.c bsp_systick.c bsp_clk.c bsp_uart.c
  group HAL
    ../hal/: hal_led.c hal_spray.c hal_water_chk.c hal_button.c hal_fan.c hal_freqhop.c hal_buzzer.c hal_flash.c hal_light.c
  group APP
    ../app/: main.c app_cmd.c app_cmd_test.c app_tasksched.c app_cmd_clko.c app_cmd_spray.c app_cmd_waterchk.c app_button.c app_led.c app_spray.c app_events.c app_cmd_event.c app_water_chk.c app_light.c app_buzzer.c app_freqhop.c
  group LIB
    ../lib/: stringx.c
